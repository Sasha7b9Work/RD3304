# Keil uVision project Reader-GD.uvprojx, settings and files
target Debug (6180000::V6.18::ARMCLANG)
  device: STM32F103TB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RD3303 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xB, ARM_MATH_CM4, DEBUG
  c include: .\src;.\src\Hardware\HAL;.\src\Hardware\CDC;..\common\STM32Cube_F1\Drivers\STM32F1xx_HAL_Driver\Inc;..\common\STM32Cube_F1\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\common\STM32Cube_F1\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\common\STM32Cube_F1\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\common\STM32Cube_F1\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\6-Reader.sct
  group src
    ./src/: opt.h main.cpp defines.h defines.cpp
  group Deivce
    ./src/Device/: Device.cpp Device.h DeviceInfo.cpp DeviceStartState.cpp
  group Hardware
    ./src/Hardware/: Timer.h Power.cpp Power.h Timer.cpp
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_gd32e23x.s system_gd32e23x.c
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.cpp HAL.h HAL_IT.cpp stm32f1xx_hal_conf.h HAL_SPI.cpp HAL_USART2.cpp HAL_ADC.cpp HAL_PINS.cpp HAL_PINS.h HAL_FLASH.cpp HAL_ROM.cpp HAL_I2C.cpp HAL_ROM_stm.cpp
  group Modules/Beeper
    ./src/Modules/Beeper/: Beeper.cpp Beeper.h Sounds.cpp Sounds.h BeeperTask.cpp
  group Modules/Memory
    ./src/Modules/Memory/: Memory.cpp Memory.h
  group Modules/CLRC66303HN
    ./src/Modules/CLRC66303HN/: CLRC66303HN.cpp CLRC66303HN.h CommandsCLRC663.cpp CommandsCLRC663.h RegistersCLRC663.cpp RegistersCLRC663.h CLRC66303_def.h
  group Modules/LIS2DH12
    ./src/Modules/LIS2DH12/: LIS2DH12.cpp LIS2DH12.h LIS2DH12_reg.h
  group Modules/Indicator
    ./src/Modules/Indicator/: Indicator.cpp Indicator.h IndicatorTask.cpp
  group Modules/Indicator/LED
    ./src/Modules/Indicator/LED/: LED.cpp LED.h
  group Modules/Indicator/LED/1-WS2812B
    ./src/Modules/Indicator/LED/1-WS2812B/: WS2812B.cpp WS2812B.h
  group Modules/Indicator/LED/2-LP5012
    ./src/Modules/Indicator/LED/2-LP5012/: DriverLP5012.cpp LP5012.cpp LP5012.h
  group Nodes
    ./src/Nodes/: Communicator.cpp Communicator.h Upgrader.cpp Upgrader.h
  group Nodes/OSDP
    ./src/Nodes/OSDP/: OSDP.cpp OSDP.h AnswersOSDP.cpp AnswersOSDP.h
  group Reader
    ./src/Reader/: Card.cpp Card.h Reader.cpp Reader.h Events.cpp Events.h Messages.cpp Messages.h Signals.cpp Signals.h
  group Reader/Task
    ./src/Reader/Task/: Task.cpp Task.h MakeUser.cpp MakeMaster.cpp
  group Settings
    ./src/Settings/: Settings.cpp Settings.h AccessCards.cpp AccessCards.h SettingsTypes.h
  group Utils
    ./src/Utils/: Buffer.h Mutex.h StringUtils.h StringUtils.cpp Log.cpp Log.h String.h String.cpp Math.cpp Math.h Debug.cpp Debug.h RingBuffer.cpp RingBuffer.h LogFunctions.cpp LogFunctions.h
target Release (6180000::V6.18::ARMCLANG)
  device: GD32E230K8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: RD3303 +hex
  AfterMake: c:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin Objects\RD3303.axf --output NFC-Reader.bin
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=2
  c define: USE_STDPERIPH_DRIVER, GD32E230
  c include: .\src;.\src\Hardware\HAL;.\src\Hardware\CDC;..\common\GD32E23x_Firmware_Library_V1.2.0\Firmware\CMSIS\GD\GD32E23x\Include;..\common\GD32E23x_Firmware_Library_V1.2.0\Firmware\CMSIS\GD\GD32E23x;..\common\GD32E23x_Firmware_Library_V1.2.0\Firmware\GD32E23x_standard_peripheral\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\6-Reader.sct
