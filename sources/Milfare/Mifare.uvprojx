# Keil uVision project Mifare.uvprojx, settings and files
target Debug (6220000::V6.22::ARMCLANG)
  device: GD32E230K8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: RD3303-799 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=2
  c define: GD32E230, TYPE_BOARD_799, DEBUG
  c include: .\src;.\src\Hardware\HAL\GD;..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x\Include;..\common\GD32E23x_Firmware_Library\Firmware\GD32E23x_standard_peripheral\Include;..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x
  memory RVCT4: ROM 0x8000000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group doc
    ../doc/: Карты.txt Команды SCPI.txt Описание.txt
  group GD32E23x
    ../common/GD32E23x_Firmware_Library/Firmware/GD32E23x_standard_peripheral/Include/: gd32e23x_adc.h gd32e23x_cmp.h gd32e23x_crc.h gd32e23x_dbg.h gd32e23x_dma.h gd32e23x_exti.h gd32e23x_fmc.h gd32e23x_fwdgt.h gd32e23x_gpio.h gd32e23x_i2c.h gd32e23x_misc.h gd32e23x_pmu.h gd32e23x_rcu.h gd32e23x_rtc.h gd32e23x_spi.h gd32e23x_syscfg.h gd32e23x_timer.h gd32e23x_usart.h gd32e23x_wwdgt.h
    ../common/GD32E23x_Firmware_Library/Firmware/GD32E23x_standard_peripheral/Source/: gd32e23x_misc.c gd32e23x_gpio.c gd32e23x_rcu.c gd32e23x_i2c.c gd32e23x_spi.c gd32e23x_dma.c gd32e23x_usart.c
  group src
    ./src/: opt.h main.cpp defines.h defines.cpp system.h
  group Hardware
    ./src/Hardware/: Timer.h Timer.cpp
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_gd32e23x.s system_gd32e23x.c
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.h HAL_PINS.h
    ./src/Hardware/HAL/GD/: gd32e23x_libopt.h HAL_I2C_gd.cpp HAL_PINS_gd.cpp HAL_ROM_gd.cpp HAL_SPI_gd.cpp HAL_IT_gd.cpp systick.h systick.cpp HAL_gd.cpp HAL_TIM5_gd.cpp HAL_TIM13_gd.cpp
  group Utils
    ./src/Utils/: Buffer.h Mutex.h StringUtils.h StringUtils.cpp Log.h String.h String.cpp Math.cpp Math.h Debug.cpp Debug.h
target Release (6220000::V6.22::ARMCLANG)
  device: GD32E230K8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: as above
  output: RD3303-799 +hex
  c flags: Optim=7 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=2
  c define: GD32E230, TYPE_BOARD_799
  c include: .\src;.\src\Hardware\HAL\GD;..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x\Include;..\common\GD32E23x_Firmware_Library\Firmware\CMSIS\GD\GD32E23x;..\common\GD32E23x_Firmware_Library\Firmware\GD32E23x_standard_peripheral\Include
  memory RVCT4: ROM 0x8000000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x2000
